PLATFORM_FLAVOR_coral-dev = "mx8mqevk"
