DESCRIPTION = "PyOpenGL is the most common cross platform Python binding to OpenGL and related APIs"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://license.txt;md5=aca224cd79879c4a6674633d31043fa8"

SRC_URI[md5sum] = "0de021941018d46d91e5a8c11c071693"
SRC_URI[sha256sum] = "9b47c5c3a094fa518ca88aeed35ae75834d53e4285512c61879f67a48c94ddaf"

PYPI_PACKAGE = "PyOpenGL"

inherit pypi setuptools3
