PLATFORM_FLAVOR:coral-dev = "mx8mqevk"
