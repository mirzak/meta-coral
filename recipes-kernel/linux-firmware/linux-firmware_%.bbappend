FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

INSANE_SKIP:linux-firmware-ath10k = "ldflags"
