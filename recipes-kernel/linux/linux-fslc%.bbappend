FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:coral-dev = " file://extra.cfg"
