FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:coral-dev = " file://extra.cfg"
