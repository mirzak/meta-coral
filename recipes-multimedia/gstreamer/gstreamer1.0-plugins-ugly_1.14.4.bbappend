PACKAGECONFIG_coral-dev ?= " \
    ${GSTREAMER_ORC} \
    a52dec mpeg2dec x264 \
"

DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_coral-dev = "1"
